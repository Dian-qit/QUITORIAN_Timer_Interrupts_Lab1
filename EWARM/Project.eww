<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\QUITORIAN_Timer_Interrupts_Lab1.ewp</path>
  </project>
  <batchBuild />
</workspace>
